# Keil uVision project stm3210c-skeleton.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: stm3210c-alarm
  c flags: Optim=2
  c include: .;Firmware;Firmware\inc;FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Firmware
    ./Firmware/: STM32F10x.s stm3210c_eval_ioe.c GLCD.c i2c_ee.c system_stm32f10x.c
    ./Firmware/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_exti.c misc.c
  group Application
    ./Firmware/: setup.c
    ./: main.c screen.c screen_test.c alarm.c alarm_test.c master_alarm.c configure_alarm.c led_display.c door1sensor.c door2sensor.c
  group FreeRTOS
    ./FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c
